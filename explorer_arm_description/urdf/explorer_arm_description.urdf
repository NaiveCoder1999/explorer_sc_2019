Commit message: arm position error

File: explorer_arm_description/urdf/explorer_arm_description.urdf (robot description, URDF)
Before this commit: robot explorer_arm_description, 11 links, 10 joints
Joints:
- joint gripper_joint: limit (none) -> lower=0.94 upper=1.88 effort=0 velocity=0
